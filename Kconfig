## Kconfig
```kconfig
config CUSTOM_TYPED_DISPLAY
    bool "Custom SSD1306 typed text OLED status screen"
    default y if ZMK_DISPLAY
    select LV_USE_IMG
```
